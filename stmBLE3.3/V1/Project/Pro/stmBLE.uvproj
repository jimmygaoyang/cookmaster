# Keil uVision project stmBLE.uvproj, settings and files
target stmBLE (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stmBLE
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\..\USER\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MDK_STARTUP
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32_LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_i2c.c
  group USER
    ../../USER/src/: main.cpp usart.c DelayFun.c GlobalIOSet.cpp RS485Trans.cpp crc.cpp dataFlash.c pos_debug.c stm32f10x_it.c BLETrans.cpp BaseProtocol.cpp OutputPro.cpp Executor.cpp MotorCycleBuf.cpp MotorDriver.cpp AmountCtrl.cpp KeyPadCtrl.cpp Context.cpp DecadeState.cpp HundredState.cpp ReadyState.cpp UnitState.cpp State.cpp LCDDriver.cpp WeightMeasure.cpp E2PROMDriver.cpp
